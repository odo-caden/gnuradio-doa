options:
  parameters:
    category: '[doa]'
    generate_options: hb
    id: xcorr_hier
    output_language: python
    title: Cross Correlation
  states: {}

blocks:
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: xcorr_width
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(xcorr_width/2)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(xcorr_width/2)
    type: complex
  states: {}
- name: doa_zero_pad_cc_0
  id: doa_zero_pad_cc
  parameters:
    vec_len_in: int(xcorr_width/2)
    vec_len_out: xcorr_width
  states: {}
- name: doa_zero_pad_cc_0_0
  id: doa_zero_pad_cc
  parameters:
    vec_len_in: int(xcorr_width/2)
    vec_len_out: xcorr_width
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: xcorr_width
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: xcorr_width
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: xcorr_width
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: xcorr_width
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: xcorr_width
  id: parameter
  parameters:
    label: Width
    type: intx
    value: 2**14
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_1, '0', doa_zero_pad_cc_0, '0']
- [blocks_stream_to_vector_1_0, '0', doa_zero_pad_cc_0_0, '0']
- [doa_zero_pad_cc_0, '0', fft_vxx_0, '0']
- [doa_zero_pad_cc_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_1, '0']
- [pad_source_0_0, '0', blocks_stream_to_vector_1_0, '0']

metadata:
  file_format: 1
