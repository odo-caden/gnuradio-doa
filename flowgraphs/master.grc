options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: master
    output_language: python
  states: {}

blocks:
- name: avg_drift
  id: variable_function_probe
  parameters:
    block_id: probe1_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: big_fft_width
  id: variable
  parameters:
    value: 2**18
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: calibrate
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Enable Calibration
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 94.5e6
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: delay
  id: variable_function_probe
  parameters:
    block_id: probe82
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: delta_samples
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: down_width
  id: variable
  parameters:
    value: n_points/downsample
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: drift
  id: variable_function_probe
  parameters:
    block_id: probe1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: drift_correction
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:2,0,1,1
    label: Angle Drift (rad/s)
    type: real
    value: drift
  states: {}
- name: drift_correction_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:2,1,1,1
    label: Avg. Angle Drift (rad/s)
    type: real
    value: avg_drift
  states: {}
- name: fft_width
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: freq_correction_default
  id: variable
  parameters:
    value: '-0.16'
  states: {}
- name: lag
  id: variable_function_probe
  parameters:
    block_id: probe3
    function_name: level
    poll_rate: '50'
    value: '0'
  states: {}
- name: lag_of_signals_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:0,2,1,1
    label: Shift from correlation
    type: int
    value: lag
  states: {}
- name: n_points
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1415926535'
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: samp_drift
  id: variable_function_probe
  parameters:
    block_id: probe72
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: slope_samples
  id: variable
  parameters:
    value: '100'
  states: {}
- name: transition
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:0,0,1,1
    label: Sample Drift (samples/sec)
    type: real
    value: samp_drift
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:4,0,1,1
    label: Capon Angle Variance
    type: int
    value: variance
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:0,1,1,1
    label: Big Delay
    type: int
    value: delay
  states: {}
- name: variance
  id: variable_function_probe
  parameters:
    block_id: probe65
    function_name: level
    poll_rate: '10'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (calibrate)*(freq_correction_default*drift) + (not calibrate)*(freq_correction_default*avg_drift)
    offset: '0'
    phase: '0'
    samp_rate: rtl_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: int(-fft_width/8)
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_width
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: lag
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: (delay>0)*delay
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: (delay<0)*-delay
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: delta_samples
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: downsample
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: downsample
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: slope_samples
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '25'
    max_iter: '4000'
    scale: 1/25.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rtl_samp_rate/float(fft_width)*calibrate
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.1*calibrate
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: delta_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(down_width)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(down_width)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: big_fft_width
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: big_fft_width
    type: complex
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: slope_samples
    type: float
  states: {}
- name: doa_capon_ccf_0_0
  id: doa_capon_ccf
  parameters:
    vlen: int(down_width)
  states: {}
- name: doa_cub_delay_cc_0
  id: doa_cub_delay_cc
  parameters:
    delay: samp_drift
    samp_rate: rtl_samp_rate
    showports: 'False'
  states: {}
- name: doa_cumulative_ff_0
  id: doa_cumulative_ff
  parameters:
    showports: 'True'
    start: '0'
  states: {}
- name: doa_cumulative_ff_0_0
  id: doa_cumulative_ff
  parameters:
    showports: 'False'
    start: '0'
  states: {}
- name: doa_cumulative_ff_0_0_0
  id: doa_cumulative_ff
  parameters:
    showports: 'False'
    start: '0'
  states: {}
- name: doa_cumulative_ff_0_1
  id: doa_cumulative_ff
  parameters:
    showports: 'True'
    start: '0'
  states: {}
- name: doa_hold_ff_0
  id: doa_hold_ff
  parameters:
    hold: not calibrate
  states: {}
- name: doa_hold_ii_0
  id: doa_hold_ii
  parameters:
    hold: not calibrate
  states: {}
- name: doa_linearslope_ff_0
  id: doa_linearslope_ff
  parameters:
    vector_size: delta_samples
  states: {}
- name: doa_linearslope_ff_0_0
  id: doa_linearslope_ff
  parameters:
    vector_size: slope_samples
  states: {}
- name: doa_peak_estimator_cif_0
  id: doa_peak_estimator_cif
  parameters:
    vector_len: fft_width
  states: {}
- name: doa_sample_offset_cci_0
  id: doa_sample_offset_cci
  parameters:
    num_xcorr: '10'
    showports: 'False'
    vector_len: big_fft_width
  states: {}
- name: doa_unwrap_ff_0
  id: doa_unwrap_ff
  parameters:
    max: '0.5'
    min: '-0.5'
    vector_size: delta_samples
  states: {}
- name: doa_unwrap_ff_0_0
  id: doa_unwrap_ff
  parameters:
    max: '3.14159265'
    min: '-3.14159265'
    vector_size: slope_samples
  states: {}
- name: doa_variance_ff_0
  id: doa_variance_ff
  parameters:
    vec_len: slope_samples
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: cutoff
    decim: '1'
    gain: '10'
    samp_rate: rtl_samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: cutoff
    decim: '1'
    gain: '10'
    samp_rate: rtl_samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_KAISER
  states: {}
- name: note_0
  id: note
  parameters:
    note: Sample alignment
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Sample feedback
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Angle feedback
  states: {}
- name: note_1
  id: note
  parameters:
    note: Alignment/Filtering
  states: {}
- name: probe1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe1_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe3
  id: blocks_probe_signal_x
  parameters:
    type: int
  states: {}
- name: probe65
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe72
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe82
  id: blocks_probe_signal_x
  parameters:
    type: int
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab@2
    is_static: 'False'
    key: recalc
    label: Recalcuate Sample Offset
    type: int
    value: '10'
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab@2
    is_static: 'False'
    key: reset_sum
    label: Reset Sample Drift Correction
    type: float
    value: '0'
  states: {}
- name: qtgui_edit_box_msg_0_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab@2
    is_pair: 'False'
    is_static: 'False'
    key: recalc
    label: Reset Alignment Buffer
    type: string
    value: reset_buffer
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0:3,0,1,3
    label1: ''
    name: '"Capon DOA Angle"'
    size: 256*4
    srate: rtl_samp_rate/float(n_points)
    type: float
    ylabel: Angle
    ymax: '3.2'
    ymin: '-3.2'
    yunit: '"radians"'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0:1,0,1,3
    label1: ''
    name: '"X-Corr Peak Delta"'
    size: delta_samples
    srate: rtl_samp_rate/float(fft_width)
    type: float
    ylabel: delta
    ymax: '0.5'
    ymin: '-0.5'
    yunit: samples
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab@1
    name: '"Cross-Correlation"'
    showports: 'True'
    vlen: fft_width
    x_axis_label: '"bins"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"magnitude^2"'
    ymax: 2e6
    ymin: '-10'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=1"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Aligned DOA
    label1: X-Corr
    label2: Messages
    num_tabs: '3'
  states: {}
- name: to_radians_per_second_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rtl_samp_rate/float(n_points)*calibrate
    type: float
  states: {}
- name: to_radians_per_second_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.1*calibrate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: data2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: aligned1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: aligned2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: capon
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: data1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: data2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: data2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: aligned1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: aligned2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: capon
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: capon
  states: {}
- name: xcorr_hier_0
  id: xcorr_hier
  parameters:
    xcorr_width: fft_width
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', probe82, '0']
- [blocks_add_xx_0, '0', probe72, '0']
- [blocks_add_xx_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_xx_0_0, '0', probe1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0_0_0, '0', doa_cub_delay_cc_0, '1']
- [blocks_delay_0_0_1, '0', doa_cub_delay_cc_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_keep_one_in_n_0_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_keep_one_in_n_1, '0', to_radians_per_second_0_0, '0']
- [blocks_moving_average_xx_0, '0', doa_hold_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', doa_cumulative_ff_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_2, '0', doa_cumulative_ff_0_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_stream_to_vector_0, '0', doa_unwrap_ff_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', doa_capon_ccf_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', doa_capon_ccf_0_0, '1']
- [blocks_stream_to_vector_1, '0', doa_sample_offset_cci_0, '1']
- [blocks_stream_to_vector_1_0, '0', doa_sample_offset_cci_0, '0']
- [blocks_stream_to_vector_2_0, '0', doa_unwrap_ff_0_0, '0']
- [doa_capon_ccf_0_0, '0', virtual_sink_2, '0']
- [doa_cub_delay_cc_0, '0', low_pass_filter_0_0, '0']
- [doa_cub_delay_cc_0, '0', virtual_sink_1, '0']
- [doa_cub_delay_cc_0, '1', blocks_delay_0_0, '0']
- [doa_cub_delay_cc_0, '1', virtual_sink_1_0, '0']
- [doa_cumulative_ff_0, '0', blocks_add_xx_0_0, '0']
- [doa_cumulative_ff_0_0, '0', blocks_add_xx_0, '1']
- [doa_cumulative_ff_0_0_0, '0', blocks_add_xx_0, '0']
- [doa_cumulative_ff_0_1, '0', blocks_add_xx_0_0, '1']
- [doa_hold_ff_0, '0', probe1_0, '0']
- [doa_hold_ii_0, '0', probe3, '0']
- [doa_linearslope_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [doa_linearslope_ff_0_0, '0', to_radians_per_second_0, '0']
- [doa_peak_estimator_cif_0, '0', doa_hold_ii_0, '0']
- [doa_peak_estimator_cif_0, '1', blocks_multiply_const_vxx_1, '0']
- [doa_sample_offset_cci_0, '0', blocks_add_const_vxx_0, '0']
- [doa_unwrap_ff_0, '0', doa_linearslope_ff_0, '0']
- [doa_unwrap_ff_0_0, '0', doa_linearslope_ff_0_0, '0']
- [doa_unwrap_ff_0_0, '0', doa_variance_ff_0, '0']
- [doa_variance_ff_0, '0', probe65, '0']
- [low_pass_filter_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_keep_one_in_n_0_1, '0']
- [qtgui_edit_box_msg_0, msg, doa_sample_offset_cci_0, recalc]
- [qtgui_edit_box_msg_0_0, msg, doa_cumulative_ff_0_0, reset]
- [qtgui_edit_box_msg_0_0, msg, doa_cumulative_ff_0_0_0, reset]
- [qtgui_edit_box_msg_0_1, msg, doa_cub_delay_cc_0, reset]
- [rtlsdr_source_0, '0', virtual_sink_0, '0']
- [rtlsdr_source_0_0, '0', virtual_sink_0_0, '0']
- [to_radians_per_second_0, '0', doa_cumulative_ff_0, '0']
- [to_radians_per_second_0_0, '0', doa_cumulative_ff_0_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_1_0, '0']
- [virtual_source_0_0, '0', blocks_delay_0_0_1, '0']
- [virtual_source_0_0_0, '0', blocks_delay_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_stream_to_vector_1, '0']
- [virtual_source_1, '0', xcorr_hier_0, '0']
- [virtual_source_1_0, '0', xcorr_hier_0, '1']
- [virtual_source_2, '0', blocks_stream_to_vector_2_0, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_2_0, '0', blocks_keep_one_in_n_1, '0']
- [xcorr_hier_0, '0', blocks_complex_to_mag_squared_0, '0']
- [xcorr_hier_0, '0', doa_peak_estimator_cif_0, '0']

metadata:
  file_format: 1
